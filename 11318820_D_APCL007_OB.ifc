Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-07-20T07:37:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 20 07:37:08 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{07FF7809-54D7-4D5C-AC24-35348D3D55AA}\ifc * Database version: 5507 * Database creation date: Tue Jul 20 07:37:07 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 20 07:37:07 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 20 07:37:07 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 59590012_D_11318820_APCL007_OB, 11318820_D_APCL007_OB:59590012_D_11318820_APCL007_OB:204598
In: Level 1
Type - Material: z_Miele_Design_Oktoblau, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 59590012_D_11318820_APCL007_OB
